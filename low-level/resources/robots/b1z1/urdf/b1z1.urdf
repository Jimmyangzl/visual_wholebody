Commit message: debugging b2 modeling in isaacgym

File: low-level/resources/robots/b1z1/urdf/b1z1.urdf (robot description, URDF)
Before this commit: robot b1z1_description, 29 links, 28 joints
Joints:
- joint base_static_joint: origin xyz=0.3 0 0.09>> rpy=0 0 0 -> xyz=0.3 0 0.09 rpy=0 0 0
